# Keil uVision project ZJXXLL_HW_WeightChannels_BSP.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ZJXXLL_HW_WeightChannels_BSP_V1.0.raf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030xC,xUSE_HAL_DRIVER,U3print_Debug,xDMA_TX
  c include: ..\User;..\User\Inc;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\User\BSP;..\User\BSP\lis3dh_STdC\driver;..\User\BSP\lis3dh_STdC\example;..\User\BSP\CH374LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_comp.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c
  group MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030xc.s
  group Include
    ../User/Inc/: hal_defs.h stm32f0xx_hal_conf.h
    ../User/: Global.h
    ../User/Main/: stm32f0xx_hal_msp.c stm32f0xx_it.c
  group BSP
    ../User/BSP/: gpio.c hal_led.c iwdg.c tim6.c usart123.c
  group User
    ../User/Main/: main.c
    ../User/: AppTask.c TimeEvent.c Variable.c UartTask.c
software components: CMSIS:CORE 5.0.1
